# Repository xboard-io/openboard

File README.md:

# openboard
True Open Hardware Board designed with open source EDA.

## KiCad design core/imx233-core.kicad_pcb

Parts:
C1, C3, C6, C7, C14, C19, C22, C23, C24, C25, C26, C27, C28, C29, C30, C33, C34, C36: 100nF; C_0603_1608Metric
C2, C9: 1uF; C_0603_1608Metric
C4, C10, C15, C16, C17, C31, C32: 10uF; C_0603_1608Metric
C8, C11, C35: 22uF; C_0805_2012Metric
C13, C20: 18pF; C_0603_1608Metric
D1: SS14; D_SOD-123
J1: Conn_01x15; PinHeader_1x15_P2.54mm_Vertical
J2, J3: Conn_01x19; PinHeader_1x19_P2.54mm_Vertical
J4: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J5: USB_B_Micro; USB_Micro-Molex
L1: 22uH; Inductor-4x4
R1, R8, R9, R10, R11, R12: 47K; R_0603_1608Metric
R3, R4, R15, R16: 1K; R_0603_1608Metric
R5: NC/0R; R_0603_1608Metric
R6: 100K; R_0603_1608Metric
R13: 10K; R_0603_1608Metric
R14: 120R; R_0603_1608Metric
TF1: TF_Card; XKXFS-N02-XXT
U1: MCIMX233CAG4C; LQFP-128_14x14_Pitch0.4mm
U2: MT46V32M16; TSSOP-66_400mil_P0.65mm
U3: SR05; SOT-143
X1: 24MHz; Crystal_SMD_3225-4P_3.2x2.5mm

Connections:
+1V0: C1.2, U1.120
+1V2: C6.2, C7.2, C8.2, C10.2, U1.1, U1.93, U1.94
+1V8: C2.2, C3.2, C16.2, U1.96, U1.110
+2V5: C11.2, C14.2, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, J1.15, R13.2, R15.1, U1.38, U1.45, U1.53, U1.106, U2.1, U2.3, U2.9, U2.15, U2.18, U2.33, U2.55, U2.61
+3V3: C15.2, C17.2, C19.2, J2.2, R1.2, R8.1, R12.1, TF1.4, U1.18, U1.92, U1.95
+4V: C4.2, D1.1 (K), U1.101
+5V: C35.2, C36.2, J3.2, J5.1 (VBUS), U1.102, U3.4
+BATT: D1.2 (A), J2.1, U1.100, U1.103
/DBG_RXD: J2.4, U1.125
/DBG_TXD: J2.5, U1.126
/EMI_A0: U1.76, U2.29
/EMI_A1: U1.75, U2.30
/EMI_A2: U1.74, U2.31
/EMI_A3: U1.73, U2.32
/EMI_A4: U1.72, U2.35
/EMI_A5: U1.71, U2.36
/EMI_A6: U1.70, U2.37
/EMI_A7: U1.69, U2.38
/EMI_A8: U1.68, U2.39
/EMI_A9: U1.67, U2.40
/EMI_A10: U1.66, U2.28
/EMI_A11: U1.65, U2.41
/EMI_A12: U1.64, U2.42
/EMI_BA0: U1.79, U2.26
/EMI_BA1: U1.80, U2.27
/EMI_CASN: U1.61, U2.22
/EMI_CE0N: R13.1, U1.63, U2.24
/EMI_CKE: U1.78, U2.44
/EMI_CLK_N: R14.2, U1.37, U2.46
/EMI_CLK_P: R14.1, U1.36, U2.45
/EMI_DQ0: U1.41, U2.2
/EMI_DQ1: U1.43, U2.5
/EMI_DQ2: U1.42, U2.4
/EMI_DQ3: U1.44, U2.7
/EMI_DQ4: U1.47, U2.8
/EMI_DQ5: U1.48, U2.10
/EMI_DQ6: U1.49, U2.11
/EMI_DQ7: U1.50, U2.13
/EMI_DQ8: U1.51, U2.54
/EMI_DQ9: U1.52, U2.56
/EMI_DQ10: U1.54, U2.57
/EMI_DQ11: U1.55, U2.59
/EMI_DQ12: U1.57, U2.65
/EMI_DQ13: U1.58, U2.63
/EMI_DQ14: U1.60, U2.60
/EMI_DQ15: U1.59, U2.62
/EMI_DQM0: U1.46, U2.20
/EMI_DQM1: U1.56, U2.47
/EMI_DQS0: U1.39, U2.16
/EMI_DQS1: U1.40, U2.51
/EMI_RASN: U1.62, U2.23
/EMI_VREF: C33.2, C34.1, R15.2, R16.1, U2.49
/EMI_WEN: U1.77, U2.21
/HPL: J2.11, U1.113
/HPR: J2.13, U1.109
/I2C_SCL: J2.8, U1.127
/I2C_SDA: J2.9, U1.128
/LCD_CS: J3.14, U1.10
/LCD_D00: J3.5, R3.2, U1.2
/LCD_D01: J3.6, R9.2, U1.3
/LCD_D02: J3.7, R10.2, U1.4
/LCD_D03: J3.8, R4.2, U1.5
/LCD_D04: J3.9, U1.6
/LCD_D05: J3.10, R11.2, U1.7
/LCD_D06: J3.11, U1.8
/LCD_D07: J3.12, U1.9
/LCD_DCLK: J1.1, U1.17
/LCD_EN: J3.15, U1.11
/LCD_HS: J3.16, U1.15
/LCD_RS: J3.13, R8.2, U1.14
/LCD_RST: J3.17, U1.12
/LCD_VS: J3.19, U1.16
/LCD_WR: J3.18, U1.13
/LRADC0: J2.14, U1.108
/LRADC1: J2.16, U1.107
/MIC: J2.10, U1.116
/P0_16: J2.6, U1.19
/P0_17: J2.7, U1.20
/P0_23: J1.14, U1.34
/P0_25: J1.11, U1.31
/P2_27: J3.3, U1.81
/P2_28: J2.17, U1.82
/PSWITCH: R6.2, U1.119
/PWM2: J2.12, U1.91
/SSP1_CMD: TF1.3, U1.83
/SSP1_D00: TF1.7, U1.84
/SSP1_D01: TF1.8, U1.85
/SSP1_D02: TF1.1, U1.86
/SSP1_D03: TF1.2, U1.87
/SSP1_DET: R1.1, TF1.9, U1.88
/SSP1_SCK: TF1.5, U1.90
/SSP_CMD: J1.4, U1.21
/SSP_D0: J1.10, U1.22
/SSP_D1: J1.2, U1.23
/SSP_D2: J1.6, U1.24
/SSP_D3: J1.9, U1.25
/SSP_D4: J1.3, U1.27
/SSP_D5: J1.7, U1.26
/SSP_D6: J1.12, U1.29
/SSP_D7: J1.8, U1.28
/SSP_DET: J1.5, U1.32
/SSP_SCK: J1.13, U1.33
/USBD_N: J5.2 (D-), U1.123, U3.3
/USBD_P: J5.3 (D+), U1.124, U3.2
/VDAC1: J2.15, U1.104
/XTALI: C20.2, U1.122, X1.3
/XTALO: C13.1, U1.121, X1.1
/sDebug: J3.4, U1.89
GND: C1.1, C2.1, C3.1, C4.1, C6.1, C7.1, C8.1, C9.2, C10.1, C11.1, C13.2, C14.1, C15.1, C16.1, C17.1, C19.1, C20.1, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C34.2, C35.1, C36.1, J2.3, J2.18, J2.19, J3.1, J4.2, J5.5 (GND), J5.6 (Shield), R5.2, R6.1, R9.1, R10.1, R11.1, R16.2, TF1.6, TF1.10, TF1.11, U1.30, U1.35, U1.98, U1.105, U1.112, U1.118, U2.6, U2.12, U2.34, U2.48, U2.52, U2.58, U2.64, U2.66, U3.1, X1.2, X1.4
unnamed: C9.1, U1.117
unnamed: J4.1, R3.1, R4.1, R5.1, R12.2
unnamed: L1.1, U1.97
unnamed: L1.2, U1.99

Notes on the sheet:
VDDA:1.8v VDDD:1.2v VDDIO:3.3v VDDXTAL:1.0v

Board: 4 copper layers, 48.3 x 48.3 mm, 58 parts (3 on the bottom side), 113 nets.

File core/Prod/v6.12/BOM.csv:

ref,value5,footprint,lib,part,description,tstamp
J4,NC,Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical,Connector_Generic,Conn_01x02,"Generic connector, single row, 01x02, script generated (kicad-library-utils/schlib/autogen/connector/)",5D9D6B43
R16,1K,Resistor_SMD:R_0603_1608Metric,Device,R,Resistor,5DC77BF3
R15,1K,Resistor_SMD:R_0603_1608Metric,Device,R,Resistor,5DC78572
C33,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5DCE452F
C34,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5DCE4B64
C23,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5DD01290
C25,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5DD0167F
C27,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5DD01903
C30,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5DD01B83
C22,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5DD7D900
C24,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5DD7DDB2
C26,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5DD7E1E2
C28,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5DD7E587
C29,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5DD7E801
C31,10uF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5DD7EAB7
C32,10uF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5DD7EDF2
D1,SS14,Diode_SMD:D_SOD-123,Device,D,Diode,5E437B1D
L1,22uH,Library:Inductor-4x4,Device,L,Inductor,5E51505E
R6,100K,Resistor_SMD:R_0603_1608Metric,Device,R,Resistor,5EA64C4B
R13,10K,Resistor_SMD:R_0603_1608Metric,Device,R,Resistor,5F190952
R9,47K,Resistor_SMD:R_0603_1608Metric,Device,R,Resistor,5F31A0B9
R10,47K,Resistor_SMD:R_0603_1608Metric,Device,R,Resistor,5F31F0F6
R11,47K,Resistor_SMD:R_0603_1608Metric,Device,R,Resistor,5F31F517
R8,47K,Resistor_SMD:R_0603_1608Metric,Device,R,Resistor,5F31F882
R3,1K,Resistor_SMD:R_0603_1608Metric,Device,R,Resistor,5F484CDE
R4,1K,Resistor_SMD:R_0603_1608Metric,Device,R,Resistor,5F4854BB
R12,47K,Resistor_SMD:R_0603_1608Metric,Device,R,Resistor,5F4B2EF8
R5,NC,Resistor_SMD:R_0603_1608Metric,Device,R,Resistor,5F4E7401
C9,1uF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5F7E3ECB
C13,18pF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5F949B92
C20,18pF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5F94A79F
R1,47K,Resistor_SMD:R_0603_1608Metric,Device,R,Resistor,5FA6F448
C1,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5FADA2E1
C2,1uF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5FB3F8A1
C3,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5FB3FC67
C8,22uF,Capacitor_SMD:C_0805_2012Metric,Device,C,Unpolarized capacitor,5FC08954
C10,10uF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5FC08C4F
C16,10uF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5FC0963B
C19,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5FC0BFF9
C4,10uF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,600919F6
R14,120R,Resistor_SMD:R_0603_1608Metric,Device,R,Resistor,5F020BA3
J1,NC,Connector_PinHeader_2.54mm:PinHeader_1x15_P2.54mm_Vertical,Connector_Generic,Conn_01x15,"Generic connector, single row, 01x15, script generated (kicad-library-utils/schlib/autogen/connector/)",5F145495
J3,NC,Connector_PinHeader_2.54mm:PinHeader_1x19_P2.54mm_Vertical,Connector_Generic,Conn_01x19,"Generic connector, single row, 01x19, script generated (kicad-library-utils/schlib/autogen/connector/)",5F19872C
J2,NC,Connector_PinHeader_2.54mm:PinHeader_1x19_P2.54mm_Vertical,Connector_Generic,Conn_01x19,"Generic connector, single row, 01x19, script generated (kicad-library-utils/schlib/autogen/connector/)",5F19521D
C15,10uF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5F23CBE6
C17,10uF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5F23EC60
C7,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5EE59F27
C6,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5EE5A51C
C11,22uF,Capacitor_SMD:C_0805_2012Metric,Device,C,Unpolarized capacitor,5F02D973
C14,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5F02FB34
C35,22uF,Capacitor_SMD:C_0805_2012Metric,Device,C,Unpolarized capacitor,5F249B98
C36,100nF,Capacitor_SMD:C_0603_1608Metric,Device,C,Unpolarized capacitor,5F249B9E
J5,USB_B_Micro,Library:USB_Micro-Molex,Connector,USB_B_Micro,USB Micro Type B connector,5F93FD89
U1,MCIMX233CAG4C,Library:LQFP-128_14x14_Pitch0.4mm,Library,MCIMX233CAG4C,,5F515ABD
TF1,TF_Card,Library:XKXFS-N02-XXT,Library,TF_Card,,5F51A132
U2,MT46V32M16,Library:TSSOP-66_400mil_P0.65mm,Library,MT46V32M16,,5F51D448
U3,SR05,Package_TO_SOT_SMD:SOT-143,Library,SR05,,5F51FD97
X1,24MHz,Library:Crystal_SMD_3225-4P_3.2x2.5mm,Library,XTAL-4,,5F52187B

## Commit log

2020-08-30 Create license as TAPR
    This license is dedicated for hardware design documentation and files.
2020-08-30 core: initial commit of openboard 1900x1900mil hw design
2020-09-01 core: Remove gerber plain files
    These files can be generated from pcb file.
    Move them into production directory as reference package.
2020-09-01 core: Add ESD protection to USB
    Update mx233 symbol & footprint library.
2020-09-01 core: Add some datasheet and production files
    v6.11 & v6.12 production files of gerber, bom, bitmap, position map
    and steel mask manufacture docs.

Notices in the files:
core/imx233-core.kicad_pcb:
TAPR Open Hardware License (www.tapr.org/OHL)
Licensed under the
